# Keil uVision project Lab2_7SegwithTrans.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Lab2_7SegwithTrans +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Lab3_7SegwithTrans.c
